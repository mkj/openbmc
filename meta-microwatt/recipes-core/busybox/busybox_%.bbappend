FILESEXTRAPATHS:prepend:witherspoon-microwatt := "${THISDIR}/files:"
SRC_URI:append:witherspoon-microwatt = " file://microwatt-busybox.cfg"
